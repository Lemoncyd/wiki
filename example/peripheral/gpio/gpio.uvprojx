# Keil uVision project gpio.uvprojx, settings and files
target gpio (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: gpio_demo +hex
  AfterMake: fromelf.exe --bin -o  ./bin  ./Objects/gpio_demo.axf
  AfterMake: fromelf.exe .\Objects\gpio_demo.axf --i32combined --output .\bin\gpio_demo.hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CFG_CP   CFG_SLEEP_MODE=PWR_MODE_SLEEP DEBUG_INFO=1 PHY_MCU_TYPE=MCU_BUMBEE_M0
  c misc: -DADV_NCONN_CFG=0x01   -DADV_CONN_CFG=0x02   -DSCAN_CFG=0x04    -DINIT_CFG=0x08   -DBROADCASTER_CFG=0x01 -DOBSERVER_CFG=0x02   -DPERIPHERAL_CFG=0x04   -DCENTRAL_CFG=0x08   -DHOST_CONFIG=0x4
  c include: ..\..\..\components\inc;..\..\..\components\osal\include;..\..\..\components\ble\include;..\..\..\components\ble\hci;..\..\..\components\ble\host;..\..\..\components\profiles\DevInfo;..\..\..\components\profiles\GATT;..\..\..\components\profiles\SimpleProfile;..\..\..\components\profiles\Roles;..\..\..\components\profiles\hrs;..\..\..\components\driver\common;..\..\..\components\driver\log;..\..\..\components\driver\gpio;..\..\..\components\driver\pwrmgr;..\..\..\components\driver\uart;..\..\..\components\driver\adc;..\..\..\components\driver\clock;..\..\..\components\driver\spi;..\..\..\components\driver\key;..\..\..\components\driver\i2c;..\..\..\components\driver\watchdog;..\..\..\components\driver\timer;..\..\..\components\driver\kscan;..\..\..\lib;.\Source;..\..\..\components\arch\cm0;..\..\..\components\ble\controller;..\..\..\misc;..\..\..\components\driver\flash;..\..\..\components\driver\pwm
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x400
  memory RVCT9: RAM 0x1fff6000 size 0x2000
  scatter file: .\scatter_load.sct
  link misc: ..\..\..\misc\bb_rom_sym_m0.txt  --keep=jump_table_base  --keep=global_config
  group arch
    ./Source/: main.c
  group jump
    ../../../misc/: jump_table.c
  group app
    ./Source/: gpio_demo.c gpio_Main.c OSAL_gpio.c
  group driver
    ../../../components/driver/gpio/: gpio.c
    ../../../components/driver/log/: my_printf.c
    ../../../components/driver/uart/: uart.c
    ../../../components/driver/pwrmgr/: pwrmgr.c
    ../../../components/driver/clock/: clock.c
    ../../../components/driver/adc/: adc.c
    ../../../components/driver/key/: key.c
    ../../../components/driver/flash/: flash.c
    ../../../components/driver/pwm/: pwm.c
  group rf
    ../../../lib/: rf.lib
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.1
