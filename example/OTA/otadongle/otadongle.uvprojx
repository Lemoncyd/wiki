# Keil uVision project otadongle.uvprojx, settings and files
target otadongle (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: singlebank_otadongle +hex
  AfterMake: fromelf.exe --bin -o  ./bin  ./Objects/singlebank_otadongle.axf
  AfterMake: fromelf -c -a -d -e -v -o singlebank_otadongle.asm ./Objects/singlebank_otadongle.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CFG_CP   PHY_MCU_TYPE=MCU_BUMBEE_M0 MTU_SIZE=247 DEBUG_INFO=3  CFG_SLEEP_MODE=PWR_MODE_NO_SLEEP  MAX_NUM_LL_CONN=1  OSAL_CBTIMER_NUM_TASKS=1  USE_FS=1 GATT_MAX_NUM_CONN = MAX_NUM_LL_CONN+1 TIM2_IRQHANDLER1_ENABLE=1
  c misc: -DADV_NCONN_CFG=0x01   -DADV_CONN_CFG=0x02   -DSCAN_CFG=0x04    -DINIT_CFG=0x08   -DBROADCASTER_CFG=0x01 -DOBSERVER_CFG=0x02   -DPERIPHERAL_CFG=0x04   -DCENTRAL_CFG=0x08   -DHOST_CONFIG=0xc
  c include: ..\..\..\components\inc;..\..\..\components\arch\cm0;..\..\..\components\profiles\Roles;..\..\..\components\profiles\DevInfo;..\..\..\components\profiles\SimpleProfile;..\..\..\components\driver\log;..\..\..\components\driver\pwrmgr;..\..\..\components\driver\uart;..\..\..\components\driver\clock;..\..\..\components\driver\gpio;..\..\..\components\driver\flash;..\..\..\components\driver\timer;..\..\..\lib;..\..\..\components\ble\include;..\..\..\components\ble\controller;..\..\..\components\ble\hci;..\..\..\components\ble\host;..\..\..\components\osal\include;..\..\..\misc;..\..\..\components\libraries\fs;..\..\..\components\profiles\ota_app;..\..\..\components\profiles\ota;..\..\..\components\libraries\crc16;..\..\..\components\profiles\ota_app;..\..\..\components\driver\watchdog
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x400
  memory RVCT9: RAM 0x1fff6000 size 0x2000
  scatter file: .\scatter_load.sct
  link misc: ..\..\..\misc\bb_rom_sym_m0.txt  --keep=jump_table_base  --keep=global_config
  group arch
    ./Source/: main.c
  group profile
    ../../../components/profiles/DevInfo/: devinfoservice.c
    ../../../components/profiles/Roles/: gap.c gapbondmgr.c gapgattserver.c peripheral.c central.c observer.c
    ../../../components/profiles/Keys/: simplekeys.c
    ../../../components/profiles/GATT/: gattservapp.c
  group jump
    ../../../misc/: jump_table.c
  group app
    ./Source/: OSAL_singlebank_otadongle.c singlebank_otadongle.c singlebank_otadongle_Main.c otam_protocol.c otam_1clk_ota.c
  group rf
    ../../../lib/: rf.lib ble_host.lib
  group driver
    ../../../components/driver/clock/: clock.c
    ../../../components/driver/pwrmgr/: pwrmgr.c
    ../../../components/driver/gpio/: gpio.c
    ../../../components/driver/uart/: uart.c
    ../../../components/driver/flash/: flash.c
    ../../../components/driver/log/: my_printf.c
    ../../../components/driver/watchdog/: watchdog.c
    ../../../components/osal/snv/: osal_snv.c
    ../../../components/libraries/crc16/: crc16.c
    ../../../components/driver/timer/: timer.c
  group fs
    ../../../components/libraries/fs/: fs.c
  group fs2
    ../../../components/libraries/fs2/: fs.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.1
