# Keil uVision project bk3432.uvproj, settings and files
target BK3432_app (ARM-ADS)
  device: ARM9E-S (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM9E)
  output: bk3432_ble_app
  AfterMake: fromelf --bin --output .\output\app\bk3432_ble_app.bin .\obj\bk3432_ble_app.axf
  AfterMake: .\output\encrypt_app.bat
  c flags: Optim=4
  c misc: --c99
  c include: .\config;.\app;..\..\libs;..\..\sdk\plactform\core_modules\src;..\..\sdk\plactform\arch;..\..\sdk\plactform\arch\compiler;..\..\sdk\plactform\arch\ll;..\..\sdk\plactform\core_modules\common\api;..\..\sdk\plactform\arch\boot;..\..\sdk\plactform\core_modules\dbg\api;..\..\sdk\plactform\core_modules\rf\api;..\..\sdk\plactform\core_modules\ecc_p256\api;..\..\sdk\plactform\arch\main;..\..\sdk\plactform\core_modules\util;..\..\sdk\plactform\driver\pwm;..\..\sdk\plactform\driver\adc;..\..\sdk\plactform\driver\audio;..\..\sdk\plactform\driver\wdt;..\..\sdk\plactform\driver\rtc;..\..\sdk\plactform\driver\i2c;..\..\sdk\plactform\driver\utc;..\..\sdk\plactform\driver\ir;..\..\sdk\plactform\driver\spi;..\..\sdk\plactform\driver\plf;..\..\sdk\plactform\driver\counter;..\..\sdk\plactform\driver\gpio;..\..\sdk\plactform\driver\intcntl;..\..\sdk\plactform\driver\icu;..\..\sdk\plactform\driver\intc;..\..\sdk\plactform\driver\flash;..\..\sdk\plactform\driver\timer;..\..\sdk\plactform\driver\reg;..\..\sdk\plactform\driver\uart;..\..\sdk\plactform\driver\emi;..\..\sdk\ble_stack\com\rwble;..\..\sdk\ble_stack\com\rwble_hl;..\..\sdk\ble_stack\com\rwble;..\..\sdk\ble_stack\com\rwip\api;..\..\sdk\ble_stack\com\rwble_hl;..\..\sdk\ble_stack\src;..\..\sdk\plactform\reg;..\..\sdk\plactform\driver\syscntl;..\..\sdk\plactform\rom\hci;..\..\sdk\plactform\core_modules\ecc_p256\api;..\..\sdk\ble_stack\inc;..\..\sdk\ble_stack\inc\hci;..\..\sdk\ble_stack\inc\h4tl;..\..\sdk\ble_stack\inc\ke;..\..\sdk\ble_stack\inc\nvds;..\..\sdk\ble_stack\inc\ea;..\..\sdk\ble_stack\inc\em;..\..\sdk\ble_stack\inc\ahi;..\..\sdk\ble_stack\inc\ble\hl\gap\gapc;..\..\sdk\ble_stack\inc\ble\hl\gap\gapm;..\..\sdk\ble_stack\inc\ble\hl\gap\smpc;..\..\sdk\ble_stack\inc\ble\hl\gap\smpm;..\..\sdk\ble_stack\inc\ble\hl\gatt\attc;..\..\sdk\ble_stack\inc\ble\hl\gatt\attm;..\..\sdk\ble_stack\inc\ble\hl\gatt\atts;..\..\sdk\ble_stack\inc\ble\hl\gatt\gattc;..\..\sdk\ble_stack\inc\ble\hl\gatt\gattm;..\..\sdk\ble_stack\inc\ble\hl\l2c\l2cc;..\..\sdk\ble_stack\inc\ble\hl\l2c\l2cm;..\..\sdk\ble_stack\inc\ble\ll\em;..\..\sdk\ble_stack\inc\ble\ll\llc;..\..\sdk\ble_stack\inc\ble\ll\lld;..\..\sdk\ble_stack\inc\ble\ll\llm;..\..\sdk\ble_stack\com\rwip\api;..\..\sdk\ble_stack\inc\ble\hl\gap;..\..\sdk\ble_stack\inc\ble\hl\gatt;..\..\sdk\ble_stack\com\prf;..\..\sdk\ble_stack\com\profiles\dis\diss\src;..\..\sdk\ble_stack\com\profiles\bas\bass\src;..\..\sdk\ble_stack\com\profiles\ancs\ancsc\api;..\..\sdk\ble_stack\com\profiles\ancs\ancsc\src;..\..\sdk\ble_stack\com\profiles\ancs;..\..\sdk\ble_stack\com\profiles\FCC0\api;..\..\sdk\ble_stack\com\profiles\FCC0\src;..\..\sdk\ble_stack\com\profiles\FCC0\util;..\..\sdk\ble_stack\com\profiles\FEE0\api;..\..\sdk\ble_stack\com\profiles\FEE0\src;..\..\sdk\ble_stack\com\profiles\hogp;..\..\sdk\ble_stack\com\profiles\hogp\hogpd\api;..\..\sdk\ble_stack\com\profiles\hogp\hogpd\src;..\..\libs;..\..\sdk\ble_stack\com\profiles\wechat\api;..\..\sdk\ble_stack\com\profiles\wechat\src;.\wechat;..\..\sdk\ble_stack\com\profiles\bas\bass;..\..\sdk\ble_stack\com\profiles\bas\bass\api;..\..\sdk\ble_stack\com\profiles\dis\diss;..\..\sdk\ble_stack\com\profiles\dis\diss\api;..\..\sdk\ble_stack\com\profiles\FFF0\api;..\..\sdk\ble_stack\com\profiles\FFF0;..\..\sdk\ble_stack\com\profiles\oad\api;..\..\sdk\plactform\driver\uart2;..\..\sdk\ble_stack\com\profiles\FFE0\api;..\..\sdk\ble_stack\com\profiles\oad\api;.\llsync\internal_inc;.\llsync;.\llsync\date_template;.\llsync\hal
  asm include: .\src\plf\refip\src\arch\ll
  library: MicroLIB
  scatter file: ..\..\sdk\project_files\link_app_1.txt
  link misc: --entry sys_Reset
  group System
    ./app/: arch_main.c
    ../../sdk/project_files/: stack_rom_symbol_1.txt
    ../../sdk/plactform/arch/boot/: boot_handlers.s boot_vectors.s
  group config
    ./config/: rwip_config.h rwprf_config.h user_config.h
  group ip
    ../../sdk/ble_stack/com/rwble_hl/: rwble_hl.c
    ../../sdk/ble_stack/com/rwble/: rwble.c
    ../../sdk/ble_stack/com/rwip/src/: rwip.c
  group driver
    ../../sdk/plactform/driver/emi/: emi.c
    ../../sdk/plactform/driver/flash/: flash.c
    ../../sdk/plactform/driver/gpio/: gpio.c
    ../../sdk/plactform/driver/icu/: icu.c
    ../../sdk/plactform/driver/intc/: intc.c
    ../../sdk/plactform/driver/pwm/: pwm.c
    ../../sdk/plactform/driver/timer/: timer.c
    ../../sdk/plactform/driver/wdt/: wdt.c
    ../../sdk/plactform/driver/uart/: uart.c
    ../../sdk/plactform/core_modules/rf/src/: rf_xvr.c
    ../../sdk/plactform/driver/uart2/: uart2.c
  group profile
    ../../sdk/ble_stack/com/prf/: prf.c prf_utils.c
    ../../sdk/ble_stack/com/profiles/FFE0/src/: ffe0s.c ffe0s_task.c attm_util128.c
  group app
    ./app/: app.c app_task.c
  group llsync
    ./llsync/core/: ble_qiot_llsync_data.c ble_qiot_llsync_device.c ble_qiot_llsync_event.c ble_qiot_llsync_ota.c ble_qiot_service.c
    ./llsync/utils/: ble_qiot_utils_base64.c ble_qiot_utils_crc.c ble_qiot_utils_hmac.c ble_qiot_utils_log.c ble_qiot_utils_md5.c ble_qiot_utils_sha1.c
    ./llsync/date_template/: ble_qiot_template.c
    ./llsync/hal/: ble_qiot_ble_device.c ble_qiot_ble_service.c
