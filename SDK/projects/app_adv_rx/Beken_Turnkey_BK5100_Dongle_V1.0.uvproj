# Keil uVision project Beken_Turnkey_BK5100_Dongle_V1.0.uvproj, settings and files
target Target 1 (MCS-51)
  device: DS80C320 Dallas Semiconductor
  cpu: IRAM(0-0xFF) CLOCK(33000000) MODDP2
  output: bk_fw +hex
  AfterMake: .\output\GenTXT.BAT
  c flags: Optimize=9
  c include: .\;..\;..\..\headfile;..\..\driver;..\..\application
  group application
    ./app/: application_main.c
    ../../application/: application_mode_normal.c application_mode_page.c application_mode_test.c application_rf.c simulate_ble_adv.c BLE_boardcast.LIB
  group driver
    ../../driver/: driver_initial.c driver_interrupt.c driver_memory.c driver_rf.c driver_timer.c driver_uart.c
